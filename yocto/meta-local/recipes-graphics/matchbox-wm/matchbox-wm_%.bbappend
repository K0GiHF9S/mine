EXTRA_OECONF += "--enable-composite"
EXTRA_OEMAKE += "-lm"
