TOOLCHAIN_TARGET_TASK += "qtwebkit-dev"
TOOLCHAIN_TARGET_TASK += "qtwebkit-mkspecs"


